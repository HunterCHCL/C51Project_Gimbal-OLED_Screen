# Keil uVision project prj.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: prj +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c delay.h keyboard.c keyboard.h OLED.c OLED.h OLED_Font.h PWM.c PWM.h UART.c UART.h main.c
